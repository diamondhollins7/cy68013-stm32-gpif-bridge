# Keil uVision project STM32_GPIF_Slave.uvprojx, settings and files
target STM32_GPIF_Slave (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: stm32_gpif_slave +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xE
  c include: .\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./src/: startup_stm32f103xe.s
  group Source
    ./src/: main.c board.c gpif_slave.c protocol.c
  group Include
    ./src/: board.h gpif_slave.h protocol.h stm32f103_regs.h
