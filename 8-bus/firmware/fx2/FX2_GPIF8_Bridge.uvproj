# Keil uVision project FX2_GPIF8_Bridge.uvproj, settings and files
target FX2_GPIF8_Bridge (MCS-51)
  device: CY7C68013A Cypress
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF) IROM(0-0x3FFF) CLOCK(24000000)
  output: fx2_gpif8_bridge +hex
  AfterMake: python ..\..\tools\hex2iic.py .\Objects\fx2_gpif8_bridge.hex .\Objects\fx2_gpif8_bridge.iic
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\cypress_fw
  group Source
    ./src/: bridge.c gpif.c dscr.a51
  group Cypress framework
    ./cypress_fw/: fw.c USBJmpTb.OBJ EZUSB.LIB
  group Include
    ./src/: bridge.h
    ./cypress_fw/: fx2.h fx2regs.h syncdly.h
