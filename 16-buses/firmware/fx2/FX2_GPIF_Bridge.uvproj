# Keil uVision project FX2_GPIF_Bridge.uvproj, settings and files
target FX2_GPIF_Bridge (MCS-51)
  device: CY7C68013A Cypress
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF) IROM(0-0x3FFF) CLOCK(24000000)
  output: fx2_gpif_bridge +hex
  AfterMake: python ..\..\tools\hex2iic.py .\Objects\fx2_gpif_bridge.hex .\Objects\fx2_gpif_bridge.iic
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source
    ./src/: main.c gpif.c descr.c
  group Include
    ./src/: bridge.h fx2regs.h
